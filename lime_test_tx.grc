options:
  parameters:
    generate_options: qt_gui
    id: lime_test_tx
    output_language: python
    title: Lime Test Tx
  states: {}

blocks:
- name: Fc
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-samp_rate/2'
    step: '1'
    stop: samp_rate/2
    value: 0.1*(samp_rate/2)
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 200e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '70'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 0.5e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '40'
    value: '10'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: Fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: '0'
    calibr_bandw_ch0: '0'
    channel_mode: '0'
    digital_bandw_ch0: '0'
    gain_dB_ch0: tx_gain
    oversample: '0'
    pa_path_ch0: '1'
    rf_freq: rf_freq
    samp_rate: samp_rate
  states: {state: disabled}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 10e6
    ch_align: 'False'
    channel_mode: '0'
    gain_dB_ch0: rx_gain
    lna_path_ch0: '2'
    oversample: '0'
    rf_freq: rf_freq
    samp_rate: samp_rate
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    plotconst: 'False'
    plottime: 'False'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    plotconst: 'False'
    plottime: 'False'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0_0, '0']
- [analog_sig_source_x_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle_0_0, '0', limesdr_sink_0, '0']
- [blocks_throttle_0_0, '0', qtgui_time_sink_x_0, '0']
- [limesdr_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
